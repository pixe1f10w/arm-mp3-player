# IAR project mp3_player.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S9B96; TARGET_IS_TEMPEST_RC5; DISK0_DK_LM3S9B96; DISK1_USB_MSC; FPM_DEFAULT
  ICCARM.CCIncludePath2: sources\application; sources\HAL\StellarisWare; sources\HAL\StellarisWare\third_party; sources\drivers; sources\drivers\Audio; sources\drivers\LCD; sources\drivers\USB\dev_msc; sources\drivers\USB\host_msc; sources\drivers\LCD; sources\drivers\LCD\LCD; sources\drivers\LCD\fonts; sources\SafeRTOS; sources\Utils; sources\libmad
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mp3_player.bin
  ILINK.IlinkOutputFile: mp3_player.out
  ILINK.IlinkIcfFile: mp3_player.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    sources/application/: button_event_task.c file_management.c idle_task.c led_task.c player_control_task.c sound_player_task.c usb_control_task.c usbotg_task.c
    sources/drivers/Audio/: mp3_decoder_task.c wav_decoder_task.c
  group Drivers
    sources/drivers/Audio/: audio_codec.c mp3_file.c
    sources/HAL/StellarisWare/third_party/fatfs/src/: ff.c
    sources/HAL/StellarisWare/third_party/fatfs/port/: mmc-dk-lm3s9b96.c
    sources/HAL/StellarisWare/drivers/: sound.c
  group Drivers/LCD
    sources/drivers/LCD/fonts/: font_engine_v1_00.c font_thai_plugin_v1_02.c font_vrinda18x16.c utils_custom_v1_02.c
    sources/drivers/LCD/LCD/: LCD_240x320.c
    sources/drivers/LCD/: lcd_print.c utils.c
  group Drivers/libmad
    sources/libmad/: bit.c decoder.c fixed.c frame.c huffman.c layer12.c layer3.c mad_timer.c stream.c synth.c version.c
  group Drivers/USB
    sources/HAL/StellarisWare/usblib/device/: usbdcdesc.c usbdconfig.c usbdenum.c usbdmsc.c
    sources/HAL/StellarisWare/usblib/: usbdesc.c usbmode.c usbtick.c
    sources/HAL/StellarisWare/usblib/host/: usbhmsc.c usbhostenum.c usbhscsi.c
  group Drivers/USB/dev
    sources/drivers/USB/dev_msc/: usb_dev_msc.c usb_msc_structs.c usbdsdcard.c
  group Drivers/USB/host
    sources/drivers/USB/host_msc/: usb_host_msc.c
  group HAL
    sources/HAL/StellarisWare/driverlib/: adc.c adc.h can.c can.h comp.c comp.h cpu.c cpu.h debug.h epi.c epi.h ethernet.c ethernet.h flash.c flash.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h i2s.c i2s.h interrupt.c interrupt.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h ssi.c ssi.h sysctl.c sysctl.h systick.c systick.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
    sources/HAL/StellarisWare/driverlib/ewarm/Exe/: driverlib.a
    sources/HAL/StellarisWare/drivers/: tlv320aic23b.c
    sources/HAL/StellarisWare/usblib/: usb-ids.h usbaudio.h usbbuffer.c usbcdc.h usbdfu.h usbhid.h usbkeyboardmap.c usblib.h usblibpriv.h usbmsc.h usbringbuf.c
    sources/HAL/StellarisWare/usblib/device/: usbdaudio.c usbdaudio.h usbdbulk.c usbdbulk.h usbdcdc.c usbdcdc.h usbdcomp.c usbdcomp.h usbdevice.h usbdevicepriv.h usbdhandler.c usbdhid.c usbdhid.h usbdhidkeyb.c usbdhidkeyb.h usbdhidmouse.c usbdhidmouse.h usbdmsc.h
    sources/HAL/StellarisWare/usblib/host/: usbhaudio.c usbhhid.c usbhhidkeyboard.c usbhhidmouse.c
    sources/HAL/StellarisWare/usblib/ewarm/Exe/: usblib.a
  group SafeRTOS
    sources/SafeRTOS/: SafeRTOS_mp3_player.c startup_ewarm.c
